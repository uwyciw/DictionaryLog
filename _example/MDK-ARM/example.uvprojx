# Keil uVision project example.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: example
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --elf --output=@L.elf !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\example.sct
  group Source Group 1
    ../: main.c startup_ARMCM7.s
    ../../Src/: dlog.c
